Commit message: Fix URDF paths for the Nessie model, and include the parameter in the launch file.

File: data/nessie.urdf (robot description, URDF)
Before this commit: robot nessie, 1 links, 0 joints
Links:
- link base_link: geometry visual mesh filename=package://vehicle_core/data/nessie.3ds
